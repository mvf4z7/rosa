/dts-vl/;
/plugin/;
/ {
compatible = "ti.beaglebone", "ti.beaglebone-black";
part-number = "EBB-PRU-Example";
version = "00A1";
/* This overlay uses the following resources */
exclusive-use = "P9.11", "P9.13", "P9.27", "P9.28", "pru0";

    gpio_pins: pinmux_gpio_pins 
        {  //The GPIO pins
        pinctrl-single,pins = 
            <
            0x070 0x07 // P9_11 MODE7 // GPIO output pull-down
            0x074 0x27 // P9_13 MODE7 // GPIO input pull-down Wrong mode???
            >;
        };
        
    pru_pru_pins: pinmux_pru_pru_pins 
        { //II The PRU pin modes
        pinctrl-single,pins = 
            <
            Oxla4 0x05 // P9_27 pr1_pru0_pru_r30_5, Mode5 output pull-down
            Ox19c 0x26 // P9_28 pr1_pru0_pru_r31_3, Mode6 input pull-down
            >;
        };
    };
};

fragment@1 
    { // Enable the PRUSS
    target = <&pruss>;
    __overlay__ {
        status = "okay";
        pinctrl-names = "default";
        pinctrl-0 = <&pru-pru-pins>;
        };
    };
    
fragment@2 
    { // Enable the GPIOs
    target = <&ocp>;
    __overlay__ {
        gpio_helper {
            compatible = "gpio-of-helper";
            status = "okay";
            pinctrl-names = "default";
            pinctrl-0 = <&gpio-pins>;
            };
        };
    };
};